# Repository ryood/4th_MFB_LPF

## EAGLE design eagle/4th_MFB_LPF/4th_MFB_LPF.brd

Parts:
C1, C3: 560pF; C050-030X075
C2: 47pF; C050-030X075
C4: 22pF; C050-030X075
C5: 0.1uF; C025-024X044
C6: 0.1uF; C050-024X044
IC1: NJM2068; DIL08
JP1: PWR; 1X03
JP2: INPUT; 1X02
JP3: OUTPUT; 1X03
R1, R3: 1.8k; 0207/7
R2: 15k; 0207/7
R4, R6: 4.7k; 0207/7
R5: 12k; 0207/7

Connections:
BYPASS: JP2.1, JP3.1, R1.1
FILTER: C4.1, IC1.7 (OUT), JP3.2, R6.2
GND: C1.2, C3.2, C5.2, C6.2, IC1.3 (+IN), IC1.5 (+IN), JP1.1, JP2.2, JP3.3
unnamed: C1.1, R1.2, R2.1, R3.1
unnamed: C2.2, IC1.2 (-IN), R2.2
unnamed: C2.1, IC1.1 (OUT), R3.2, R4.1
unnamed: C3.1, R4.2, R5.1, R6.1
unnamed: C4.2, IC1.6 (-IN), R5.2
V+: C6.1, IC1.8 (V+), JP1.2
V-: C5.1, IC1.4 (V-), JP1.3

Notes on the sheet:
4Pin(V-)と8Pin(V+)の位置が普通と逆なので注意

Board: 2 copper layers, 31.4 x 40.6 mm, 16 parts (0 on the bottom side), 10 nets.

## EAGLE design eagle/Rail_Splitter/Rail_Splitter.brd

Parts:
C1: 1uF; C050-035X075
C2, C3: 100uF; SANYO-OSCON_C6
IC1: TLE2426CP; DIP-8
JP1: IN; 1X02
JP2: OUT; 1X03
LED1: GREEN; LED3MM
R1: 3.3k; 0207/7

Connections:
unnamed: C1.1, IC1.8 (NR)
unnamed: C2.-, C3.+, IC1.1 (OUT), JP2.2
unnamed: LED1.A, R1.1
V+: C2.+, IC1.3 (IN), JP1.1, JP2.1, R1.2
V-: C1.2, C3.-, IC1.2 (COM), JP1.2, JP2.3, LED1.K (C)

Board: 2 copper layers, 27.6 x 27.9 mm, 8 parts (0 on the bottom side), 5 nets.

## Commit log

2016-04-01 回路図修正
2016-04-01 テスト表追加
2016-04-01 png追加
2016-04-03 ケース加工図を追加
